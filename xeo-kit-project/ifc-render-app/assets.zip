Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2019-02-08T09:25:02
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20181011_1645(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Feb 08 09:25:02 2019 * Host: DESKTOP-JP69TCS * Database: C:\Users\GIULIO~1\AppData\Local\Temp\{CA04F18C-145C-4915-A815-10C53B61676C}\ifc * Database version: 5507 * Database creation date: Fri Feb 08 09:25:00 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Feb 08 09:25:01 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Feb 08 09:25:01 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nome del progetto; Phase: Stato del progetto

# IfcSite, Default
RefLatitude: 42, 12, 46, 804504; RefLongitude: -71, -2, 0, -602416; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 0
