Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Furniture_Sofas-Armchairs_Rubelli_PALAZZO-SOFA.ifc
Time: 2019-10-23T10:03:36
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFurnishingElement, PALAZZO SOFA
ePset_BIMobjectScript - Metal finish detail: 56-Satin brass; LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): PALAZZO SOFA; SKU (BO_prodsku): PALAZZO-SOFA; ManufacturName (BO_Manufac): Rubelli; BrandUrl (BO_brandurl): http://www.rubelli.com; ProductFamily (BO_prodfam): Rubelli Casa; ProductGroup (BO_prodgroup): Sofa; ManufacturCountry (BO_mancont): Italy; DesignCountry (BO_designcont): Italy; PublishDate (BO_publisdat): 10/1/2019; EditionNumber (BO_edinum): 1; Width (BO_width): 2240; Height (BO_height): 830; Depth (BO_depth): 960; Weight (BO_weight): 72; QR (BO_boqrurl): http://bimobject.com/rubelli/product/PALAZZO-SOFA; ProductDataUrl (BO_prodaturl): bimobject.com/rubelli/product/PALAZZO-SOFA; ProductUrl (BO_producturl): http://www.rubelli.com/en/palazzo-sofa-12083.html?___SID=U; TechnicalDescription (BO_techcert): http://www.rubelli.com/en/palazzo-sofa-12083.html?___SID=U; BimObjectMainCategory (BO_bomaincat): Furniture; BimObjectMainCategoryCode (BO_bomaincat_code): furniture; BimObjectCategory (BO_bocat): Sofas & Armchairs; BimObjectCategoryCode (BO_bocat_code): furniture-sofas-armchairs; IfcClassification (BO_ifcclas): Furnishing Element; UnspcCode (BO_unspc): 56; Uniclass14Code (BO_uniclass_1_4_code): JN; Uniclass14Description (BO_uniclass_1_4_desc): Furniture/Equipment; OmniClassCode (BO_omniclass_code): 23-21 23 00; OmniClassDescription (BO_omniclass_name): Residential Furniture and Equipment; MasterFormat2014Code (BO_masterformat2014_code): 12 58 00; MasterFormat2014Description (BO_masterformat2014_name): Residential Furniture; RegionEurope (BO_europe): AD, AL, AT, AX, BA, BE, BG, BY, CH, CY, CZ, DE, DK, EE, ES, FI, FO, FR, GB, GG, GI, GR, HR, HU, IE, IM, IS, IT, JE, LI, LT, LU, LV, MC, MD, ME, MK, MT, NL, NO, PL, PT, RO, RS, RU, SE, SI, SJ, SK, SM, UA, VA; RegionNorthAmerica (BO_northamerica): AG, AI, AW, BB, BL, BM, BQ, BS, BZ, CA, CR, CU, CW, DM, DO, GD, GL, GP, GT, HN, HT, JM, KN, KY, LC, MF, MQ, MS, MX, NI, PA, PM, PR, SV, SX, TC, TT, US, VC, VG, VI; RegionSouthAmerica (BO_southamerica): AR, BO, BR, CL, CO, EC, FK, GF, GY, PE, PY, SR, UY, VE; RegionMiddleEast (BO_middleeast): AE, AF, BH, EG, IL, IQ, IR, JO, KW, LB, OM, PS, QA, SA, SY, TR, YE; RegionAsia (BO_asia): AM, AZ, BD, BN, BT, CC, CN, CX, GE, HK, ID, IN, IO, JP, KG, KH, KP, KR, KZ, LA, LK, MM, MN, MO, MV, MY, NP, PH, PK, SG, TH, TJ, TM, TW, UZ, VN; RegionOceania (BO_oceania): AS, AU, CK, FJ, FM, GU, KI, MH, MP, NC, NF, NR, NU, NZ, PF, PG, PN, PW, SB, TK, TL, TO, TV, UM, WF, WS, VU; RegionAfrica (BO_africa): AO, BF, BI, BJ, BW, CD, CF, CG, CI, CM, CV, DJ, DZ, EH, ER, ET, GA, GH, GM, GN, GQ, GW, KE, KM, LR, LS, LY, MA, MG, ML, MR, MU, MW, MZ, NA, NE, NG, RE, RW, SC, SD, SH, SL, SN, SO, SS, ST, SZ, TD, TG, TN, TZ, UG, YT, ZA, ZM, ZW; RegionAntarctica (BO_antarctica): AQ, BV, GS, HM, TF
