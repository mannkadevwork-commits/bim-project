Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[DesignTransferView]
File name: /dev/null
Time: 2026-07-15T21:05:14+05:30
Written by: IfcOpenShell 0.8.4.post1
Made in: IfcOpenShell 0.8.4.post1
Authorization: Nobody

# IfcDoor, Revolving Commercial Door
In: Ground Floor
OverallHeight: 2.1 m; OverallWidth: 2 m
