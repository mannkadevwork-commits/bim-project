Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[DesignTransferView]
File name: /dev/null
Time: 2026-07-17T08:50:14+05:30
Written by: IfcOpenShell 0.8.5
Made in: IfcOpenShell 0.8.5
Authorization: Nobody

# IfcDoor, 3BHK Interior Door
In: Ground Floor
OverallHeight: 2.1 m; OverallWidth: 0.9 m
