Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, SurfaceGeometryAddOnView], Option [Elements to export: Visible elements (on all stories)], Option [Partial Structure Display: Entire Model], Option [IFC Domain: All], Option [Structural Function: All Elements], Option [Convert Grid elements: On], Option [Convert IFC Annotations and Archicad 2D elements: Off], Option [Convert 2D symbols of Doors and Windows: Off], Option [Export geometries that Participates in Collision Detection only: On], Option [Split complex elements: Off], Option [Material Preservation: Explode all], Option [IFC Model position: Survey Point and Project Origin], Option [Curtain Wall export mode: Single Element], Option [Railing export mode: Single Element], Option [Stair export mode: Single Element], Option [Properties To Export: All properties], Option [Space containment: Off], Option [Geometry to type objects: Off], Option [Element Properties: Off], Option [Building Material Properties: Off], Option [Element Parameters: Off], Option [Component Parameters: Off], Option [IFC Base Quantities: Off], Option [Door Window Parameters: On], Option [IFC Space boundaries: Off], Option [Archicad Zone Categories as IFC Space classification data: Off], Option [Element Classifications: On]
File name: D:\PROYECTOS\2025\ROCA\PENDIENTES\ROCA SANITARIO B165.01-W106.01\B165.01 RFA\BIMOBJECT\852466xxx\Sanitary_Compound_Units_ROCA_852466xxx_Furniture_Optica-Pack-Base-unit-with-six-drawers-,-double-ceramic-basin,-mirror-and-LED-spotlight.ifc
Time: 2025-11-17T15:33:56
Author: Architect
Organization: Building Designer Office
Written by: DDS_IFC v3.0
Made in: IFC file generated by Graphisoft Archicad 27.0.0 SPA FULL Windows version (IFC add-on version: 3001 SPA FULL).
Authorization: The authorising person

# IfcSite, Sitio
RefLatitude: 40, 24, 59, 760000; RefLongitude: -3, -42, -59, -760000; RefElevation: 0 mm

# IfcBuildingStorey, Planta Baja
In: Construcción
Elevation: 0 mm

# IfcDistributionFlowElement: Sanitary_Compound_Units_ROCA_852466xxx_Furniture_Optica-Pack-Base-unit-with-six-drawers-,-double-ceramic-basin,-mirror-and-LED-spotlight, FU - 001
In: Planta Baja
Type - ElementType: Distribution Flow Element; PredefinedType: USERDEFINED
Classification: Elemento de Flujo de Distribución (Clasificación de Archicad)
Pset_DesignOptions - Design Option Set: Modelo Principal; Design Option: Modelo Principal
AC_Pset_RenovationAndPhasing - Renovation Status: New
