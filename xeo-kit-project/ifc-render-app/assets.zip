Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CET Designer IFC Export]
File name: Bookcase QBUS, 2 shelves, base frame, 1252x400x400 mm.ifc
Time: 2023-01-04 10:25:57
Written by: IFC Interface 13.05.50
Made in: CET Designer 13.05.50.00

# IfcFurnishingElement, Hylla [QBUS], 2 hyllplan, 1152x400x400 mm, ljusgrå
In: Site
Type - Description: Hylla [QBUS], 2 hyllplan, 1152x400x400 mm, ljusgrå
Pset_ManufacturerTypeInformation - Manufacturer: AJ Produkter
Pset_CETData - PartList: 1 x 1838505, 1 x 1701505
