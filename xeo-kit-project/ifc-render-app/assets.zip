Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Sanitary_Installation-Systems_Roca_IN-WALL-EP1.ifc
Time: 2020-07-13T17:17:21
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFlowController: IN-WALL EP1
ePset_BIMobjectScript - LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): IN-WALL EP1; SKU (BO_prodsku): 890102008; ManufacturName (BO_Manufac): Roca; BrandUrl (BO_brandurl): http://www.roca.com; ProductFamily (BO_prodfam): In-Wall; ProductGroup (BO_prodgroup): OPERATING PLATE; ManufacturCountry (BO_mancont): Spain; DesignCountry (BO_designcont): Spain; PublishDate (BO_publisdat): 7/14/2020; EditionNumber (BO_edinum): 1; Width (BO_width): 250; Height (BO_height): 160; Depth (BO_depth): 0; Weight (BO_weight): 0; QR (BO_boqrurl): http://bimobject.com/roca/product/890102008; ProductDataUrl (BO_prodaturl): bimobject.com/roca/product/890102008; ProductUrl (BO_producturl): http://www.export.roca.com/catalogue/collections/installation-systems/wall-066-14.0360/ep1-electronic-glass-finished-operating-plate-concealed-cistern-automatic-touchless-dual-flush-adjustable-light-multiple-colour-choice-890102008#!A890102008; InstallationInstructions (BO_montins): http://www.export.roca.com/RocaResourceServlet/resources/getMainResource?idObject=%7B93346402-75E9-49F4-8BD4-5E93D054D46F%7D; TechnicalDescription (BO_techcert): http://www.export.roca.com/RocaResourceServlet/resources/getMainResource?idObject=%7B2712B346-E0DA-4FC5-B676-97C44DF3306D%7D; InstructionVideo (BO_youtube): https://www.youtube.com/watch?v=68jtjk-3_i4; MaterialMain (BO_mainmat): Glass; BimObjectMainCategory (BO_bomaincat): Sanitary; BimObjectMainCategoryCode (BO_bomaincat_code): sanitary; BimObjectCategory (BO_bocat): Installation Systems; BimObjectCategoryCode (BO_bocat_code): sanitary-installation-systems; IfcClassification (BO_ifcclas): Actuator; Uniclass2015Code (BO_uniclass2015_code): Pr_40_20_93_91; Uniclass2015Description (BO_uniclass2015_desc): WC flushing valves; OmniClassCode (BO_omniclass_code): 23-27 33 00; OmniClassDescription (BO_omniclass_name): Valve Actuators; UniFormat2Code (BO_uniformat2_code): D2010; UniFormat2Description (BO_uniformat2_name): Plumbing Fixtures; RegionEurope (BO_europe): All; RegionNorthAmerica (BO_northamerica): All; RegionSouthAmerica (BO_southamerica): All; RegionMiddleEast (BO_middleeast): All; RegionAsia (BO_asia): All; RegionOceania (BO_oceania): All; RegionAfrica (BO_africa): All; RegionAntarctica (BO_antarctica): All
