Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: f0550_armoire_resuscitation.ifc
Time: 2016-02-22T15:32:48
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2015
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFurnishingElement: F0550 - Armoire, Resuscitation
ePset_BIMobject_Lena - LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): F0550 - Armoire, Resuscitation; SKU (BO_prodsku): F0550; ManufacturName (BO_Manufac): SEPS2BIM; ManufacturCountry (BO_mancont): United States; DesignCountry (BO_designcont): United States; PublishDate (BO_publisdat): 2014-08-12; EditionNumber (BO_edinum): 1; Width (BO_width): 910; Height (BO_height): 2030; Depth (BO_depth): 910; Weight (BO_weight): 0; QR (BO_boqrurl): http://bimobject.com/seps2bim/product/F0550; ProductDataUrl (BO_prodaturl): bimobject.com/seps2bim/product/F0550; IfcClassification (BO_ifcclas): Furnishing Element; RegionNorthAmerica (BO_northamerica): US
