Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: norden_mattress_cabinet_b150xd60xh150_birch.ifc
Time: 2017-05-24T09:09:15
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2015
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFurnishingElement: Norden mattress cabinet B150xD60xH150 birch
ePset_BIMobject_Lena - Front: White S0500-N; LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): Norden mattress cabinet B150xD60xH150 birch; SKU (BO_prodsku): 80542; ManufacturName (BO_Manufac): Lekolar; BrandUrl (BO_brandurl): https://www.lekolar.se/; ProductFamily (BO_prodfam): Norden; ProductGroup (BO_prodgroup): Storage; ManufacturCountry (BO_mancont): Sweden; DesignCountry (BO_designcont): Sweden; EditionNumber (BO_edinum): 1; Width (BO_width): 1500; Height (BO_height): 1500; Depth (BO_depth): 600; Weight (BO_weight): 0; QR (BO_boqrurl): http://bimobject.com/lekolar/product/80542; ProductDataUrl (BO_prodaturl): bimobject.com/lekolar/product/80542; ProductUrl (BO_producturl): https://www.lekolar.se/sortiment/mobler-inredning/skotrum/forvaring/norden-madrasskap-b150xd60xh150-bjork/; MaterialMain (BO_mainmat): Wood; BimObjectCategory (BO_bocat): Shelving & Storage; IfcClassification (BO_ifcclas): Furniture; UnspcCode (BO_unspc): 56; Uniclass14Code (BO_uniclass_1_4_code): L8211; Uniclass14Description (BO_uniclass_1_4_desc): Furniture; Uniclass20Code (BO_uniclass_2_0_code): PR-31-77; Uniclass20Description (BO_uniclass_2_0_desc): Shelves And Storage Units; NBSReference (BO_nbs_ref): 31-77; NBSReferenceDescription (BO_nbs_desc): Shelves And Storage Units; RegionEurope (BO_europe): DK, FI, NO, SE
