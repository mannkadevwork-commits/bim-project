Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: frame_25_mirror_cabinet_1300_mm_with_ambient_lighting_with_out_socket_without_sensor_switch.ifc
Time: 2016-09-22T08:32:18
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2015
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFurnishingElement: FRAME 25 Mirror cabinet 1300 mm, with ambient lighting, with out socket, without sensor switch
ePset_BIMobject_Lena - Charge Code: 900 CREATED IN WF F900; Main material: 145 Glass with white backing; LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): FRAME 25 Mirror cabinet 1300 mm, with ambient lighting, with out socket, without sensor switch; SKU (BO_prodsku): 408774; ManufacturName (BO_Manufac): LAUFEN; ProductFamily (BO_prodfam): FRAME 25; ProductGroup (BO_prodgroup): Mirror cabinets; ManufacturCountry (BO_mancont): Germany; DesignCountry (BO_designcont): Switzerland; PublishDate (BO_publisdat): 6/2/2016; EditionNumber (BO_edinum): 2; Width (BO_width): 1300; Height (BO_height): 750; Depth (BO_depth): 150; Weight (BO_weight): 30.2; QR (BO_boqrurl): http://bimobject.com/laufen/product/408774; ProductDataUrl (BO_prodaturl): bimobject.com/laufen/product/408774; InstallationInstructions (BO_montins): http://www.export.laufen.com/ResourceServlet/resources/getMainResource?idObject={6FC60AA7-A0CF-4270-B911-C170E1E601D6}; ProductCertification (BO_prodcert): http://www.export.laufen.com/en/service/certificates; TechnicalDescription (BO_techcert): http://www.export.laufen.com/ResourceServlet/resources/getMainResource?idObject={AD42C5F7-68B5-477C-AD6B-B4F7ACE94E4C}; MaterialMain (BO_mainmat): Aluminium; BimObjectCategory (BO_bocat): Shelving & Storage; IfcClassification (BO_ifcclas): Furnishing Element; Uniclass14Code (BO_uniclass_1_4_code): L72141; Uniclass14Description (BO_uniclass_1_4_desc): Cabinets; RegionEurope (BO_europe): All; RegionNorthAmerica (BO_northamerica): All; RegionSouthAmerica (BO_southamerica): All; RegionMiddleEast (BO_middleeast): All; RegionAsia (BO_asia): All; RegionOceania (BO_oceania): All; RegionAfrica (BO_africa): All; RegionAntarctica (BO_antarctica): All
